# Keil uVision project project.uvproj, settings and files
target RT-Thread STM32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=870
  c include: ..\..\STM32F10x_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\rt-thread\include;..\..\STM32F10x_Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\STM32F10x_Libraries\CMSIS\CM3\CoreSupport;..\..\rt-thread\components\dfs;.;..\..\rt-thread\components\dfs\include;..\..\rt-thread\components\finsh;..\..\rt-thread\libcpu\arm\stm32
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group STM32_StdPeriph
    ../../STM32F10x_Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../STM32F10x_Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c misc.c
  group Kernel
    ../../rt-thread/kernel/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c module.c object.c rtm.c scheduler.c slab.c thread.c timer.c
  group finsh
    ../../rt-thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group Filesystem
    ../../rt-thread/components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group STM32
    ../../rt-thread/libcpu/arm/stm32/: cpu.c fault.c interrupt.c serial.c stack.c context_rvds.S fault_rvds.S start_rvds.S
  group Startup
    ./: application.c board.c sdcard.c startup.c stm32f10x_it.c system_stm32f10x.c usart.c utils.c spi_flash.c sst25vfxx.c at45dbxx.c
  group rzsz
    ./rzsz/: sz.c rz.c zcore.c zstart.c zdevice.c
